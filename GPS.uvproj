# Keil uVision project GPS.uvproj, settings and files
target GPS (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GPS
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: startup_TM4C123.s main.c utils.h utils.c
  group gpio
    ./gpio/: gpio.c tm4c123gh6ph.h gpio.h
  group uart
    ./uart/: UART.c UART.h tm4c123gh6pm.h
  group gps
    ./gps/: gps.c gps.h
